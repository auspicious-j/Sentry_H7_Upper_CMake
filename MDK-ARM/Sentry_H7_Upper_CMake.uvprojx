# Keil uVision project Sentry_H7_Upper_CMake.uvprojx, settings and files
target Sentry_H7_Upper_CMake (6240000::V6.24::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: Sentry_H7_Upper_CMake +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;..\Middlewares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../ApplicationCpp;../ApplicationCpp/App;../ApplicationCpp/App/Inc;../ApplicationCpp/Comms;../ApplicationCpp/Comms/Inc;../ApplicationCpp/Drivers;../ApplicationCpp/Drivers/Inc;../ApplicationCpp/Framework;../ApplicationCpp/Platform;../ApplicationCpp/Graph;../ApplicationCpp/Graph/Gimbal;../ApplicationCpp/Graph/Gimbal/Control_Node;../ApplicationCpp/Graph/Gimbal/Input_Node;../ApplicationCpp/Graph/Gimbal/Output_Node;../ApplicationCpp/Graph/Gimbal/State_Node;../ApplicationCpp/Graph/Gimbal/Target_Node;../ApplicationCpp/Graph/Chassis;../ApplicationCpp/Graph/Chassis/Input_Node;../ApplicationCpp/Graph/Chassis/Kinematics_Node;../ApplicationCpp/Graph/Chassis/Mode_Node;../ApplicationCpp/Graph/Shooter;../ApplicationCpp/Graph/Shooter/Input_Node;../ApplicationCpp/Graph/Shooter/Logic_Node;../ApplicationCpp/Io;../ApplicationCpp/Io/Vision;../ApplicationCpp/Io/Inputs;../Platform;../Platform/STM32;../BSP/inc;../BSP/src;../IMU/Algorithm/inc;../IMU/Algorithm/src;../IMU/BMI088/inc;../IMU/BMI088;../IMU/inc;../IMU/src;../IMU/Mahony/inc;../IMU/Mahony/src;../math/inc;../math/src
  asm include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fdcan.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group ApplicationCpp/App
    ../ApplicationCpp/App/: BeepApp.cpp ChassisApp.cpp GimbalApp.cpp JudgeApp.cpp MotoApp.cpp ShooterApp.cpp UserFreertosApp.cpp VisionApp.cpp
  group ApplicationCpp/Comms
    ../ApplicationCpp/Comms/: BoardToBoardApp.cpp RcReceiverApp.cpp
  group ApplicationCpp/Drivers
    ../ApplicationCpp/Drivers/: DeviceDetectApp.cpp MotorDriverApp.cpp
  group ApplicationCpp/Framework
    ../ApplicationCpp/Framework/: PluginGraph.cpp
  group ApplicationCpp/Graph/Gimbal
    ../ApplicationCpp/Graph/Gimbal/: Gimbal_Graph.cpp Vision_Target_Node.cpp
    ../ApplicationCpp/Graph/Gimbal/Control_Node/: Gimbal_Control_Node.cpp
    ../ApplicationCpp/Graph/Gimbal/Input_Node/: Gimbal_Input_Node.cpp
    ../ApplicationCpp/Graph/Gimbal/Output_Node/: Gimbal_Output_Node.cpp
    ../ApplicationCpp/Graph/Gimbal/State_Node/: Gimbal_State_Node.cpp
    ../ApplicationCpp/Graph/Gimbal/Target_Node/: Gimbal_Target_Node.cpp
  group ApplicationCpp/Graph/Chassis
    ../ApplicationCpp/Graph/Chassis/: Chassis_Graph.cpp
    ../ApplicationCpp/Graph/Chassis/Input_Node/: Chassis_Input_Node.cpp
    ../ApplicationCpp/Graph/Chassis/Kinematics_Node/: Chassis_Kinematics_Node.cpp
    ../ApplicationCpp/Graph/Chassis/Mode_Node/: Chassis_Mode_Node.cpp
  group ApplicationCpp/Graph/Shooter
    ../ApplicationCpp/Graph/Shooter/: Shooter_Graph.cpp
    ../ApplicationCpp/Graph/Shooter/Input_Node/: Shooter_Input_Node.cpp
    ../ApplicationCpp/Graph/Shooter/Logic_Node/: Shooter_Logic_Node.cpp
  group ApplicationCpp/Io
    ../ApplicationCpp/Io/Inputs/: RobotInputs.cpp
    ../ApplicationCpp/Io/Vision/: VisionLink.cpp VisionProtocol.cpp VisionTargetMailbox.cpp
  group Platform/STM32
    ../Platform/STM32/: Stm32Clock.cpp Stm32Profiler.cpp
  group BSP
    ../BSP/src/: bsp_can.c bsp_dwt.c bsp_ws2812.c
  group IMU
    ../IMU/Algorithm/src/: kalman_filter.c QuaternionEKF.c
    ../IMU/BMI088/: BMI088driver.c BMI088Middleware.c
    ../IMU/src/: imu_temp_ctrl.c
  group math
    ../math/src/: Crc.c myQueue.c PID.c Slope.c degree.c dji_angle.c
software components: CMSIS:CORE 6.1.1, CMSIS:DSP 1.16.2
